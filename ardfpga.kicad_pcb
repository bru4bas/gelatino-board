# Repository bru4bas/gelatino-board

File README.md:

# gelatino-board
Arduino meets iCE40 FPGA

This project is meant to be a low-cost FPGA development board, targeting education (Verilog and FPGA) and hobbist users and employing exclusively open-source software and hardware.

It is based on the iCE40LP384 FPGA from Lattice Semiconductor, embedded together with a ATMega328 Arduino-like hardware. Both MCU and FPGA can work together in the Arduino compatible board, and shall be programmed using the traditional Arduino IDE, with extensions. FPGA programming is carried out by the ATMega MCU itself, with an extension of the Arduino standard bootloader -- transfering data to the Flash serial memory, that is shared by both devices.

All hardware is being developed with KiCAD and is published as open-source (GPL).

The main ideas of the project are:
  * Low-lost -- use the cheapest possible components
  * Relative simplicity of production, even hand-made -- avoid smaller IC packages (like BGA)
  * Open-source software only: Arduino environment (avr-gcc, avrdude, ...) and icestorm framework (yosys, icestorm, nextpnr, ...)

Up to now, the project roadmap is
- [x] Preliminary electronic design
- [x] Preliminary bill-of-materials (components from lcsc.com)
- [x] Initial PCB design
- [ ] Conclusion of electronic design and final BOM
- [ ] Building and testing a prototype
- [ ] Changing the Arduino Bootloader for providing FPGA Flash memory programming
- [ ] Coding a extension for the Arduino IDE to deal with Verilog files
  
  Everyone interested in joining this project is welcome!
  
  Many thanks to FPGA WARS, for most of electronic design was inspired from -- mainly the board Alhambra II -- and the amazing projects Yosys and IceStorm.

## KiCad design ardfpga.kicad_pcb

Parts:
C1, C2: 33pF; 0603_CAP
C3: 100nF; 0603_CAP
CD1, CD2, CD3, CD4, CD5, CD6, CD7, CD8, CD9, CD10, CD11, CD12: 100nF; 0603_CAP
CH1: RESET; SW_SPST_TL3305A
D1: D_Schottky_Small_ALT; SOT-23
D4, D5: LED_Small_ALT; 0603_LED
IOH1: Conn_01x08; PinSocket_1x08_P2.54mm_Vertical
IOL1: Conn_01x08; PinSocket_1x08_P2.54mm_Vertical
J1: AD; PinSocket_1x06_P2.54mm_Vertical
J2: PWR; PinSocket_1x06_P2.54mm_Vertical
J3: ICSP; PinHeader_2x03_P2.54mm_Vertical
Q1, Q2: NMOS; SOT-23
R1, R3, R5, R6, R7, R8, R9: 10k; 0603_RES
R2, R4: 100; 0603_RES
R10, R11, R12, R13: 1k; 0603_RES
R14, R15: 220; 0603_RES
RN1, RN2, RN3, RN4: 100; R_Array_Concave_4x0603
RN5, RN6, RN7, RN8, RN9: 1k; R_Array_Concave_4x0603
U1: iCE40LP384; QFN-32-1EP_5x5mm_P0.5mm_EP3.1x3.1mm
U2: AT25xxx; SOIC-8_3.9x4.9mm_P1.27mm
U3: ATMega328; TQFP-32_7x7mm_P0.8mm
U4: CH340G; SOIC-16_3.9x9.9mm_P1.27mm
X1: 16MHz; Oscillator_SMD_Abracon_ASE-4Pin_3.2x2.5mm
X2: 12 MHz; Oscillator_SMD_Abracon_ASE-4Pin_3.2x2.5mm

Connections:
+1.2V: CD6.1, U1.25 (VCC); also elsewhere on the board
+3.3V: CD1.1, CD2.1, CD3.1, CD4.1, CD5.1, CD7.1, CD9.2, CD10.1, CD11.1, D1.2 (A), J2.2, R1.1, R3.1, R5.1, R6.1, R7.2, R8.1, R9.2, R14.2, U1.4 (VCCIO), U1.9 (VCCIO), U1.16 (VSPI), U1.17 (VCCIO), U1.28 (VCCIO), U2.8 (VCC), U3.4 (VCC), U3.6 (VCC), U3.18 (AVCC), U4.4 (V3), U4.16 (VCC), X1.1 (OE), X1.4 (V+); also elsewhere on the board
+5V: J2.3, J3.2; also elsewhere on the board
AD0: RN2.4 (R4.1), RN9.1 (R1.1), U3.23 (PC0)
AD1: RN2.3 (R3.1), RN9.2 (R2.1), U3.24 (PC1)
AD2: RN2.2 (R2.1), RN9.3 (R3.1), U3.25 (PC2)
AD3: RN2.1 (R1.1), RN9.4 (R4.1), U3.26 (PC3)
AD4: Q2.G, R12.1, U3.27 (PC4)
AD5: Q1.G, R13.1, U3.28 (PC5)
AREF: RN8.5 (R4.2), U3.20 (AREF)
CLK16: U1.18 (R34), U3.7 (PB6), X1.3 (OUT)
DONE: R6.2, U1.11 (DONE), U3.22 (ADC7)
DTR: C3.1, U4.13 (~DTR)
FRST: Q1.D, R5.2, U1.10 (RST)
FSCK: R8.2, RN4.1 (R1.1), U1.15 (SCK), U2.6 (SCK)
FSDI: RN4.3 (R3.1), U1.13 (SDI), U2.2 (MISO)
FSDO: RN4.2 (R2.1), U1.12 (SDO), U2.5 (MOSI)
FSEL: Q1.S, Q2.S, U3.8 (PB7)
FSS: Q2.D, R1.2, U1.14 (SS), U2.1 (~CS)
IO0: R2.1, R10.2, RN5.8 (R1.2), U3.30 (PD0)
IO1: R4.1, R11.2, RN5.7 (R2.2), U3.31 (PD1)
IO2: RN3.5 (R4.2), RN5.6 (R3.2), U3.32 (PD2)
IO3: RN3.6 (R3.2), RN5.5 (R4.2), U3.1 (PD3)
IO4: RN3.7 (R2.2), RN6.8 (R1.2), U3.2 (PD4)
IO5: RN3.8 (R1.2), RN6.7 (R2.2), U3.9 (PD5)
IO6: RN1.1 (R1.1), RN6.6 (R3.2), U3.10 (PD6)
IO7: RN1.2 (R2.1), RN6.5 (R4.2), U3.11 (PD7)
IO8: RN1.3 (R3.1), RN7.8 (R1.2), U3.12 (PB0)
IO9: RN1.4 (R4.1), RN7.7 (R2.2), U3.13 (PB1)
MRST: C3.2, CH1.2, J2.1, J3.5, R9.1, U3.29 (~RESET)
MSCK: J3.3, R15.2, RN4.8 (R1.2), RN8.7 (R2.2), U3.17 (PB5)
MSDI: J3.1, RN4.7 (R2.2), RN8.8 (R1.2), U3.16 (PB4)
MSDO: J3.4, RN4.6 (R3.2), RN7.5 (R4.2), U3.15 (PB3)
MSS: RN7.6 (R3.2), U3.14 (PB2)
unnamed: C1.2, U4.7 (XI), X2.2
unnamed: C2.2, U4.8 (XO), X2.1
unnamed: CD8.1, D1.1 (K), U1.24 (VPP)
unnamed: CD12.1, IOH1.8, RN8.4 (R4.1)
unnamed: D4.2, R14.1
unnamed: D5.2, R15.1
unnamed: IOH1.1, RN7.1 (R1.1)
unnamed: IOH1.2, RN7.2 (R2.1)
unnamed: IOH1.3, RN7.3 (R3.1)
unnamed: IOH1.4, RN7.4 (R4.1)
unnamed: IOH1.5, RN8.1 (R1.1)
unnamed: IOH1.6, RN8.2 (R2.1)
unnamed: IOL1.1, RN5.1 (R1.1)
unnamed: IOL1.2, RN5.2 (R2.1)
unnamed: IOL1.3, RN5.3 (R3.1)
unnamed: IOL1.4, RN5.4 (R4.1)
unnamed: IOL1.5, RN6.1 (R1.1)
unnamed: IOL1.6, RN6.2 (R2.1)
unnamed: IOL1.7, RN6.3 (R3.1)
unnamed: IOL1.8, RN6.4 (R4.1)
unnamed: J1.1, RN9.8 (R1.2)
unnamed: J1.2, RN9.7 (R2.2)
unnamed: J1.3, RN9.6 (R3.2)
unnamed: J1.4, RN9.5 (R4.2)
unnamed: J1.5, R12.2
unnamed: J1.6, R13.2
unnamed: R2.2, U1.2 (L2A)
unnamed: R3.2, U2.7 (~HOLD)
unnamed: R4.2, U1.1 (L2B)
unnamed: R7.1, U2.3 (~WP)
unnamed: R10.1, U4.2 (TXD)
unnamed: R11.1, U4.3 (RXD)
unnamed: RN1.5 (R4.2), U1.8 (L5A)
unnamed: RN1.6 (R3.2), U1.7 (L5B)
unnamed: RN1.7 (R2.2), U1.6 (L4B)
unnamed: RN1.8 (R1.2), U1.5 (L4A)
unnamed: RN2.5 (R4.2), U1.32 (T52)
unnamed: RN2.6 (R3.2), U1.31 (T53)
unnamed: RN2.7 (R2.2), U1.30 (T50)
unnamed: RN2.8 (R1.2), U1.29 (T49)
unnamed: RN3.1 (R1.1), U1.23 (R39)
unnamed: RN3.2 (R2.1), U1.22 (R38)
unnamed: RN3.3 (R3.1), U1.20 (R36)
unnamed: RN3.4 (R4.1), U1.19 (R35)
USB_D+: U4.5 (UD+); also elsewhere on the board
USB_D-: U4.6 (UD-); also elsewhere on the board

Parts:
C4, C5: 10uF; 1206_SMD
C6, C7, C8, C9: 1uF; 0805_SMD
D2, D3: D_Schottky_Small_ALT; SOT-23
J4: USB; USB-Micro-LCSC
J5: POWER; BarrelJack_Wuerth_6941xx301002
U5: AMS1117-5.0; SOT-223-3_TabPin2
U6: RT9013-33; SOT-23-5
U7: RT9013-12; SOT-23-5

Connections:
+1.2V: C9.1, U7.5 (Vout); also elsewhere on the board
+3.3V: C8.1, U6.5 (Vout); also elsewhere on the board
+5V: C5.1, C6.1, C7.1, D2.1 (K), U5.2 (VO), U6.1 (Vin), U6.3 (EN), U7.1 (Vin), U7.3 (EN); also elsewhere on the board
unnamed: D2.2 (A), J4.1
unnamed: D3.2 (A), J5.1
USB_D+: J4.3; also elsewhere on the board
USB_D-: J4.2; also elsewhere on the board
V+: C4.1, D3.1 (K), U5.3 (VI)

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
Board: 2 copper layers, 69.0 x 53.8 mm, 69 parts (0 on the bottom side), 84 nets.

## Commit log

2021-03-24 Kicad files for Gelatino Board first commit.
2021-03-24 Added 3d image of the board for github README file.
2021-05-16 Board routed, circuit changed to ease PCB routing. Minor adjustments. Ready to re-check PCB.
2021-05-24 Board revision, leds added. Better routing.
2021-05-25 Bugs in the board corrected. Better routing. First BOM version.
2021-07-14 Add kitspace.yaml
2021-07-14 Add price column title to BOM
